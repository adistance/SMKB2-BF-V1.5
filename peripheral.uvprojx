# Keil uVision project peripheral.uvprojx, settings and files
target ble_peripheral (5050041::V5.05 (build 41)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  BeforeMake: .\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: .\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SUPPORT_ALONE_UPPERSTACK_IMG,CUSTOMIZED_TUYA_BLE_CONFIG_FILE=<custom_tuya_ble_config.h>
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: .\sdk\bin\upperstack_img\upperstack_0_0;.\sdk\inc\app;.\sdk\inc\bluetooth\gap;.\sdk\inc\bluetooth\gap\gap_lib;.\sdk\inc\bluetooth\profile;.\sdk\inc\bluetooth\profile\server;.\sdk\inc\bluetooth\profile\client;.\sdk\inc\os;.\sdk\inc\peripheral;.\sdk\inc\platform;.\sdk\src\sample\ble_peripheral;..\ble_peripheral;.\driver;.\driver\Sensor;.\driver\MLlib;.\driver\MLlib\algo;.\driver\MLlib\filesys;.\driver\MLlib\protocol;.\driver\Menu;.\driver\Menu\module;.\sdk\src\dfu;..\source;.\driver\Menu\bluetooth\crypto;.\driver\Menu\bluetooth;.\driver\Menu\fingerprint;.\driver\ML1680;.\driver\MLlib\algo\include;.\driver\Tuya;.\driver\Tuya\components;.\driver\Tuya\inc;.\driver\Tuya\sample_app;.\driver\MLlib\algo\include;..\source_algo_new_flash_V1.5
  asm misc: --cpreproc
  asm include: ..\..\..\inc\platform
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off --diag_suppress=L6436W --no_strict_wchar_size --fpu=VFPv4_D16 --diag_suppress=L6329
  group include
    ./sdk/inc/platform/: rom_uuid.h app_define.h
  group lib
    ./sdk/bin/: ROM.lib sbee2_sdk.lib adc.lib
    ./sdk/bin/upperstack_img/upperstack_0_0/: gap_utils.lib
    ./driver/Tuya/lib/: tuya_ble_sdk_lib_arm_m4f_keil.lib
    ./driver/MLlib/algo/source/: fps.lib
  group cmsis
    ./sdk/src/mcu/rtl876x/arm/: startup_rtl876x.s
    ./sdk/src/mcu/rtl876x/: system_rtl876x.c
  group peripheral
    ./sdk/src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_nvic.c rtl876x_pinmux.c rtl876x_gpio.c rtl876x_rcc.c rtl876x_spi.c rtl876x_gdma.c rtl876x_uart.c rtl876x_aon_wdg.c rtl876x_tim.c rtl876x_rtc.c rtl876x_adc.c
  group profile
    ./sdk/src/ble/profile/server/: simple_ble_service.c ota_service.c dfu_service.c
    ./sdk/src/ble/profile/client/: ancs_client.c
  group dfu_task
    ./sdk/src/dfu/: dfu_application.c dfu_main.c dfu_task.c aes256.c
    ./sdk/src/platform/: dfu_flash.c
  group app
    ./sdk/src/sample/ble_peripheral/: ancs.c app_task.c main.c peripheral_app.c aes_wrap.c
    ./sdk/src/mcu/rtl876x/: overlay_mgr.c
    ./sdk/src/platform/: os_msg.c
  group driver
    ./driver/: driver_delay.c driver_led.c driver_spi.c driver_flash.c driver_sensor.c driver_uart.c driver_wdg.c driver_rtc.c driver_motor.c driver_button.c driver_usbkey.c driver_I2C.c driver_hal.c
  group sensor
    ./driver/ML1680/: sensor.c SensorAdjust.c
  group ml_driver
    ./driver/MLlib/algo/: action.c
    ./driver/MLlib/protocol/: command.c protocol.c
    ./driver/MLlib/filesys/: filesys.c files_ftrsys.c
    ./driver/MLlib/: mlapi.c system_setting.c
  group menu
    ./driver/Menu/: menu_manage.c menu_sleep.c
    ./driver/Menu/bluetooth/crypto/: base64.c password.c record.c
    ./driver/Menu/fingerprint/: fingerprint.c
  group module
    ./driver/Menu/module/: module.c
  group tuya
    ./driver/Tuya/: tuya_ble_port.c tuya_ble_port_peripheral.c tuya_ble_port_rtl8762.c tuya_ble_service_rtl8762d.c
    ./driver/Tuya/components/: hmac.c md5.c sha1.c sha256.c
    ./driver/Tuya/sample_app/: custom_app_product_test.c tuya_ble_app_demo.c tuya_ble_app_ota.c tuya_ble_app_production_test.c tuya_ble_sdk_test.c
    ./driver/Tuya/src/: tuya_ble_api.c tuya_ble_bulk_data.c tuya_ble_data_handler.c tuya_ble_event.c tuya_ble_event_handler.c tuya_ble_event_handler_weak.c tuya_ble_gatt_send_queue.c tuya_ble_heap.c tuya_ble_main.c tuya_ble_mem.c tuya_ble_mutli_tsf_protocol.c tuya_ble_queue.c tuya_ble_storage.c tuya_ble_unix_time.c tuya_ble_utils.c
